## boards/shields/j1okabe/Kconfig.defconfig
```kconfig
if SHIELD_J1OKABE

config ZMK_KEYBOARD_NAME
    default "j1okabe"

endif # SHIELD_J1OKABE
```
